# Keil uVision project Lticker.uvproj, settings and files
target Lticker (ARM-ADS)
  device: CY8C4245AXI-483 Cypress
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x0-0x7FFF) CLOCK(4800000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Lticker +hex
  AfterMake: .\Generated_Source\PSoC4\postbuild.bat "#L"
  c flags: Optim=1 wLevel=2
  c define: NDEBUG
  c include: .;.\Generated_Source\PSoC4
  asm define: NDEBUG
  asm include: .;.\Generated_Source\PSoC4
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Generated_Source\PSoC4\Cm0RealView.scat
  link misc: ./Generated_Source/PSoC4/ARM_Keil_MDK/CyComponentLibrary.a
  group Generated_Header
    ./Generated_Source/PSoC4/: Clock_1.h CyFlash.h CyLib.h Pin_1.h Pin_1_aliases.h Pin_2.h Pin_2_aliases.h Pin_3.h Pin_3_aliases.h core_cm0.h core_cm0_psoc4.h core_cmFunc.h core_cmInstr.h cyPm.h cydevice_trm.h cydevicegnu_trm.inc cydeviceiar_trm.inc cydevicerv_trm.inc cydisabledsheets.h cyfitter.h cyfitter_cfg.h cyfittergnu.inc cyfitteriar.inc cyfitterrv.inc cypins.h cytypes.h project.h
  group Generated_Source
    ./Generated_Source/PSoC4/: Clock_1.c Cm0Start.c CyFlash.c CyLib.c Pin_1.c Pin_2.c Pin_3.c cyPm.c cyfitter_cfg.c cymetadata.c cyutils.c CyBootAsmRv.s
  group Source
    ./: main.c
